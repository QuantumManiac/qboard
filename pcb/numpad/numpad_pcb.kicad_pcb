# Repository QuantumManiac/qboard

File README.md:

# QBoard
A custom (almost) full-size mechanical keyboard with a detachable numpad

## Pictures

## BOM
A BOM of parts used can be found [here](https://github.com/QuantumManiac/qboard/tree/main/bom)

## Firmware
Rough notes for configuring the MCU and flashing firmware can be found [here](https://github.com/QuantumManiac/qboard/tree/main/qmk_firmware)

## Improvements
- Improving on the numpad connector - don't fit well and when connected isn't sturdy
- Switching out direct soldering of keyswitches onto PCB with hot-swap sockets

## KiCad design pcb/numpad/numpad_pcb.kicad_pcb

Parts:
D1: NUMLOCK; LED_D3.0mm_Clear
D2: POWER; LED_D3.0mm_Clear
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: Conn_01x16_Female; PinSocket_2x08_P2.54mm_Horizontal
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX9, MX10, MX11, MX12, MX13, MX14, MX17: MX-LED; MXOnly-1U
MX8, MX15: MX-LED; MXOnly-2U-ReversedVerticalStabilizers
MX16: MX-LED; MXOnly-2U-FLIPPED-ReversedStabilizers
R1, R2: 1.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal

Connections:
+5V: D2.2 (A), J1.16, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2
GND: J1.15, R1.1, R2.1
LEDGND: J1.10, MX1.4 (LEDGND), MX2.4 (LEDGND), MX3.4 (LEDGND), MX4.4 (LEDGND), MX5.4 (LEDGND), MX6.4 (LEDGND), MX7.4 (LEDGND), MX8.4 (LEDGND), MX9.4 (LEDGND), MX10.4 (LEDGND), MX11.4 (LEDGND), MX12.4 (LEDGND), MX13.4 (LEDGND), MX14.4 (LEDGND), MX15.4 (LEDGND), MX16.4 (LEDGND), MX17.4 (LEDGND)
NUMLOCK: D1.2 (A), J1.11
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: D3.2 (A), MX2.2 (ROW)
unnamed: D4.2 (A), MX3.2 (ROW)
unnamed: D5.2 (A), MX4.2 (ROW)
unnamed: D6.2 (A), MX1.2 (ROW)
unnamed: D7.2 (A), MX5.2 (ROW)
unnamed: D8.2 (A), MX6.2 (ROW)
unnamed: D9.2 (A), MX7.2 (ROW)
unnamed: D10.2 (A), MX8.2 (ROW)
unnamed: D11.2 (A), MX9.2 (ROW)
unnamed: D12.2 (A), MX10.2 (ROW)
unnamed: D13.2 (A), MX11.2 (ROW)
unnamed: D14.2 (A), MX12.2 (ROW)
unnamed: D15.2 (A), MX13.2 (ROW)
unnamed: D16.2 (A), MX14.2 (ROW)
unnamed: D17.2 (A), MX15.2 (ROW)
unnamed: D18.2 (A), MX16.2 (ROW)
unnamed: D19.2 (A), MX17.2 (ROW)
unnamed: MX1.3 (LED), R11.1
unnamed: MX2.3 (LED), R3.1
unnamed: MX3.3 (LED), R4.1
unnamed: MX4.3 (LED), R5.1
unnamed: MX5.3 (LED), R6.1
unnamed: MX6.3 (LED), R7.1
unnamed: MX7.3 (LED), R8.1
unnamed: MX8.3 (LED), R9.1
unnamed: MX9.3 (LED), R10.1
unnamed: MX10.3 (LED), R12.1
unnamed: MX11.3 (LED), R13.1
unnamed: MX12.3 (LED), R14.1
unnamed: MX13.3 (LED), R15.1
unnamed: MX14.3 (LED), R16.1
unnamed: MX15.3 (LED), R17.1
unnamed: MX16.3 (LED), R18.1
unnamed: MX17.3 (LED), R19.1
col16: J1.9, MX1.1 (COL), MX5.1 (COL), MX9.1 (COL), MX12.1 (COL), MX16.1 (COL)
col17: J1.8, MX2.1 (COL), MX6.1 (COL), MX10.1 (COL), MX13.1 (COL)
col18: J1.7, MX3.1 (COL), MX7.1 (COL), MX11.1 (COL), MX14.1 (COL), MX17.1 (COL)
col19: J1.6, MX4.1 (COL), MX8.1 (COL), MX15.1 (COL)
row0: D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J1.5
row1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J1.4
row2: D11.1 (K), D12.1 (K), D13.1 (K), J1.3
row3: D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), J1.2
row4: D18.1 (K), D19.1 (K), J1.1

Board: 2 copper layers, 81.0 x 160.2 mm, 56 parts (0 on the bottom side), 49 nets.

## KiCad design pcb/main_front/main_pcb.kicad_pcb

Parts:
C1: 4.7u; CP_Radial_D4.0mm_P1.50mm
C2, C3: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C4, C5: 22p; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1: CAPSLOCK; LED_D3.0mm_Clear
D3, D4: 3.6V; D_DO-35_SOD27_P7.62mm_Horizontal
D5: POWER; LED_D3.0mm_Clear
D6: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
F1: Fuse; C_Disc_D5.0mm_W2.5mm_P5.00mm
J1: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4085
J3: Conn_01x16_Male; PinHeader_2x08_P2.54mm_Horizontal
Q1: Q_NMOS_GDS; TO-262-3_Vertical
R1: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R11: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R3, R5: 5.1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R4, R6, R10: 1.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R7, R8: 75R; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
SW1: RESET; SW_PUSH_6mm
SW2: BOOT; SW_PUSH_6mm
SW3: BL_STEP; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
U1: ATmega32-16PU; DIP-40_W15.24mm
Y1: Crystal; Crystal_HC49-4H_Vertical

Connections:
+5V: C1.1, C2.1, C3.1, D5.2 (A), F1.1, J1.2 (VCC), J3.16, R4.1, R11.1, U1.10 (VCC), U1.30 (AVCC); also elsewhere on the board
BOOT: SW2.1, U1.20 (PD6)
CAPSLOCK: D1.2 (A), U1.34 (PA6)
D+: R8.1, U1.16 (PD2)
D-: R7.1, U1.17 (PD3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D3.2 (A), D4.2 (A), J1.6 (GND), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.15, Q1.3, R2.2, R3.1, R5.1, R6.1, R10.1, SW1.2, SW2.2, U1.11 (GND), U1.31 (GND)
LEDGND: J3.10, Q1.2; also elsewhere on the board
LEDPWM: R1.2, U1.18 (PD4)
NUMLOCK: J3.11, U1.33 (PA7)
unnamed: C4.1, U1.13 (XTAL1), Y1.2
unnamed: C5.1, U1.12 (XTAL2), Y1.1
unnamed: D1.1 (K), R6.2
unnamed: D3.1 (K), J2.A6 (D+), J2.B6 (D+), R8.2
unnamed: D4.1 (K), J2.A7 (D-), J2.B7 (D-), R4.2, R7.2
unnamed: D5.1 (K), R10.2
unnamed: D6.2 (A), SW3.2
unnamed: F1.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J2.A5 (CC1), R3.2
unnamed: J2.B5 (CC2), R5.2
unnamed: Q1.1, R1.1, R2.1
RESET: J1.5 (~RST), R11.2, SW1.1, U1.9 (~RESET)
col0: U1.1 (PB0); also elsewhere on the board
col1: SW3.1, U1.2 (PB1); also elsewhere on the board
col2: U1.3 (PB2); also elsewhere on the board
col3: U1.4 (PB3); also elsewhere on the board
col4: U1.5 (PB4); also elsewhere on the board
col5: J1.4 (MOSI), U1.6 (PB5); also elsewhere on the board
col6: J1.1 (MISO), U1.7 (PB6); also elsewhere on the board
col7: J1.3 (SCK), U1.8 (PB7); also elsewhere on the board
col8: U1.14 (PD0); also elsewhere on the board
col9: U1.15 (PD1); also elsewhere on the board
col10: U1.19 (PD5); also elsewhere on the board
col11: U1.21 (PD7); also elsewhere on the board
col12: U1.29 (PC7); also elsewhere on the board
col13: U1.28 (PC6); also elsewhere on the board
col14: U1.27 (PC5); also elsewhere on the board
col15: U1.26 (PC4); also elsewhere on the board
col16: J3.9, U1.25 (PC3)
col17: J3.8, U1.24 (PC2)
col18: J3.7, U1.23 (PC1)
col19: J3.6, U1.22 (PC0)
row0: D6.1 (K), J3.5, U1.40 (PA0); also elsewhere on the board
row1: J3.4, U1.39 (PA1); also elsewhere on the board
row2: J3.3, U1.38 (PA2); also elsewhere on the board
row3: J3.2, U1.37 (PA3); also elsewhere on the board
row4: J3.1, U1.36 (PA4); also elsewhere on the board
row5: U1.35 (PA5); also elsewhere on the board

Parts:
D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX30, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX43, MX44, MX45, MX46, MX47, MX48, MX50, MX56, MX57, MX58, MX59, MX60, MX61, MX62, MX63, MX64, MX65, MX66, MX68, MX73, MX74, MX75, MX76, MX77, MX78, MX79, MX80, MX81, MX82, MX84, MX85, MX94, MX95, MX96, MX97, MX98, MX99: MX-LED; MXOnly-1U
MX29: MX-LED; MXOnly-2U
MX35, MX49: MX-LED; MXOnly-1.5U
MX55, MX83: MX-LED; MXOnly-1.75U
MX67: MX-LED; MXOnly-2.25U-FLIPPED
MX72: MX-LED; MXOnly-2.25U
MX90, MX91, MX92: MX-LED; MXOnly-1.25U
MX93: MX-LED; MXOnly-6.25U-ReversedStabilizers
R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal

Connections:
+5V: R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R61.2, R66.2, R67.2, R68.2, R69.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, R76.2, R77.2, R78.2, R79.2, R83.2, R84.2, R85.2, R86.2, R87.2, R88.2, R89.2, R90.2, R91.2, R92.2, R93.2, R94.2, R95.2, R96.2, R101.2, R102.2, R103.2, R104.2, R105.2, R106.2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; also elsewhere on the board
LEDGND: MX1.4 (LEDGND), MX2.4 (LEDGND), MX3.4 (LEDGND), MX4.4 (LEDGND), MX5.4 (LEDGND), MX6.4 (LEDGND), MX7.4 (LEDGND), MX8.4 (LEDGND), MX9.4 (LEDGND), MX10.4 (LEDGND), MX11.4 (LEDGND), MX12.4 (LEDGND), MX13.4 (LEDGND), MX14.4 (LEDGND), MX15.4 (LEDGND), MX16.4 (LEDGND), MX17.4 (LEDGND), MX18.4 (LEDGND), MX19.4 (LEDGND), MX20.4 (LEDGND), MX21.4 (LEDGND), MX22.4 (LEDGND), MX23.4 (LEDGND), MX24.4 (LEDGND), MX25.4 (LEDGND), MX26.4 (LEDGND), MX27.4 (LEDGND), MX28.4 (LEDGND), MX29.4 (LEDGND), MX30.4 (LEDGND), MX35.4 (LEDGND), MX36.4 (LEDGND), MX37.4 (LEDGND), MX38.4 (LEDGND), MX39.4 (LEDGND), MX40.4 (LEDGND), MX41.4 (LEDGND), MX42.4 (LEDGND), MX43.4 (LEDGND), MX44.4 (LEDGND), MX45.4 (LEDGND), MX46.4 (LEDGND), MX47.4 (LEDGND), MX48.4 (LEDGND), MX49.4 (LEDGND), MX50.4 (LEDGND), MX55.4 (LEDGND), MX56.4 (LEDGND), MX57.4 (LEDGND), MX58.4 (LEDGND), MX59.4 (LEDGND), MX60.4 (LEDGND), MX61.4 (LEDGND), MX62.4 (LEDGND), MX63.4 (LEDGND), MX64.4 (LEDGND), MX65.4 (LEDGND), MX66.4 (LEDGND), MX67.4 (LEDGND), MX68.4 (LEDGND), MX72.4 (LEDGND), MX73.4 (LEDGND), MX74.4 (LEDGND), MX75.4 (LEDGND), MX76.4 (LEDGND), MX77.4 (LEDGND), MX78.4 (LEDGND), MX79.4 (LEDGND), MX80.4 (LEDGND), MX81.4 (LEDGND), MX82.4 (LEDGND), MX83.4 (LEDGND), MX84.4 (LEDGND), MX85.4 (LEDGND), MX90.4 (LEDGND), MX91.4 (LEDGND), MX92.4 (LEDGND), MX93.4 (LEDGND), MX94.4 (LEDGND), MX95.4 (LEDGND)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; also elsewhere on the board
unnamed: D7.2 (A), MX1.2 (ROW)
unnamed: D8.2 (A), MX2.2 (ROW)
unnamed: D9.2 (A), MX3.2 (ROW)
unnamed: D10.2 (A), MX4.2 (ROW)
unnamed: D11.2 (A), MX5.2 (ROW)
unnamed: D12.2 (A), MX6.2 (ROW)
unnamed: D13.2 (A), MX7.2 (ROW)
unnamed: D14.2 (A), MX8.2 (ROW)
unnamed: D15.2 (A), MX9.2 (ROW)
unnamed: D16.2 (A), MX10.2 (ROW)
unnamed: D17.2 (A), MX11.2 (ROW)
unnamed: D18.2 (A), MX12.2 (ROW)
unnamed: D19.2 (A), MX13.2 (ROW)
unnamed: D20.2 (A), MX14.2 (ROW)
unnamed: D21.2 (A), MX15.2 (ROW)
unnamed: D22.2 (A), MX16.2 (ROW)
unnamed: D23.2 (A), MX17.2 (ROW)
unnamed: D24.2 (A), MX18.2 (ROW)
unnamed: D25.2 (A), MX19.2 (ROW)
unnamed: D26.2 (A), MX20.2 (ROW)
unnamed: D27.2 (A), MX21.2 (ROW)
unnamed: D28.2 (A), MX22.2 (ROW)
unnamed: D29.2 (A), MX23.2 (ROW)
unnamed: D30.2 (A), MX24.2 (ROW)
unnamed: D31.2 (A), MX25.2 (ROW)
unnamed: D32.2 (A), MX26.2 (ROW)
unnamed: D33.2 (A), MX27.2 (ROW)
unnamed: D34.2 (A), MX28.2 (ROW)
unnamed: D35.2 (A), MX29.2 (ROW)
unnamed: D36.2 (A), MX30.2 (ROW)
unnamed: D41.2 (A), MX35.2 (ROW)
unnamed: D42.2 (A), MX36.2 (ROW)
unnamed: D43.2 (A), MX37.2 (ROW)
unnamed: D44.2 (A), MX38.2 (ROW)
unnamed: D45.2 (A), MX39.2 (ROW)
unnamed: D46.2 (A), MX40.2 (ROW)
unnamed: D47.2 (A), MX41.2 (ROW)
unnamed: D48.2 (A), MX42.2 (ROW)
unnamed: D49.2 (A), MX43.2 (ROW)
unnamed: D50.2 (A), MX44.2 (ROW)
unnamed: D51.2 (A), MX45.2 (ROW)
unnamed: D52.2 (A), MX46.2 (ROW)
unnamed: D53.2 (A), MX47.2 (ROW)
unnamed: D54.2 (A), MX48.2 (ROW)
unnamed: D55.2 (A), MX49.2 (ROW)
unnamed: D56.2 (A), MX50.2 (ROW)
unnamed: D61.2 (A), MX55.2 (ROW)
unnamed: D62.2 (A), MX56.2 (ROW)
unnamed: D63.2 (A), MX57.2 (ROW)
unnamed: D64.2 (A), MX58.2 (ROW)
unnamed: D65.2 (A), MX59.2 (ROW)
unnamed: D66.2 (A), MX60.2 (ROW)
unnamed: D67.2 (A), MX61.2 (ROW)
unnamed: D68.2 (A), MX62.2 (ROW)
unnamed: D69.2 (A), MX63.2 (ROW)
unnamed: D70.2 (A), MX64.2 (ROW)
unnamed: D71.2 (A), MX65.2 (ROW)
unnamed: D72.2 (A), MX66.2 (ROW)
unnamed: D73.2 (A), MX67.2 (ROW)
unnamed: D74.2 (A), MX68.2 (ROW)
unnamed: D78.2 (A), MX72.2 (ROW)
unnamed: D79.2 (A), MX73.2 (ROW)
unnamed: D80.2 (A), MX74.2 (ROW)
unnamed: D81.2 (A), MX75.2 (ROW)
unnamed: D82.2 (A), MX76.2 (ROW)
unnamed: D83.2 (A), MX77.2 (ROW)
unnamed: D84.2 (A), MX78.2 (ROW)
unnamed: D85.2 (A), MX79.2 (ROW)
unnamed: D86.2 (A), MX80.2 (ROW)
unnamed: D87.2 (A), MX81.2 (ROW)
unnamed: D88.2 (A), MX82.2 (ROW)
unnamed: D89.2 (A), MX83.2 (ROW)
unnamed: D90.2 (A), MX84.2 (ROW)
unnamed: D91.2 (A), MX85.2 (ROW)
unnamed: D96.2 (A), MX90.2 (ROW)
unnamed: D97.2 (A), MX91.2 (ROW)
unnamed: D98.2 (A), MX92.2 (ROW)
unnamed: D99.2 (A), MX93.2 (ROW)
unnamed: D100.2 (A), MX94.2 (ROW)
unnamed: D101.2 (A), MX95.2 (ROW)
unnamed: D102.2 (A), MX96.2 (ROW)
unnamed: D103.2 (A), MX97.2 (ROW)
unnamed: D104.2 (A), MX98.2 (ROW)
unnamed: D105.2 (A), MX99.2 (ROW)
unnamed: MX1.3 (LED), R12.1
unnamed: MX2.3 (LED), R13.1
unnamed: MX3.3 (LED), R14.1
unnamed: MX4.3 (LED), R15.1
unnamed: MX5.3 (LED), R16.1
unnamed: MX6.3 (LED), R17.1
unnamed: MX7.3 (LED), R18.1
unnamed: MX8.3 (LED), R19.1
unnamed: MX9.3 (LED), R20.1
unnamed: MX10.3 (LED), R21.1
unnamed: MX11.3 (LED), R22.1
unnamed: MX12.3 (LED), R23.1
unnamed: MX13.3 (LED), R24.1
unnamed: MX14.3 (LED), R25.1
unnamed: MX15.3 (LED), R26.1
unnamed: MX16.3 (LED), R27.1
unnamed: MX17.3 (LED), R28.1
unnamed: MX18.3 (LED), R29.1
unnamed: MX19.3 (LED), R30.1
unnamed: MX20.3 (LED), R31.1
unnamed: MX21.3 (LED), R32.1
unnamed: MX22.3 (LED), R33.1
unnamed: MX23.3 (LED), R34.1
unnamed: MX24.3 (LED), R35.1
unnamed: MX25.3 (LED), R36.1
unnamed: MX26.3 (LED), R37.1
unnamed: MX27.3 (LED), R38.1
unnamed: MX28.3 (LED), R39.1
unnamed: MX29.3 (LED), R40.1
unnamed: MX30.3 (LED), R41.1
unnamed: MX35.3 (LED), R46.1
unnamed: MX36.3 (LED), R47.1
unnamed: MX37.3 (LED), R48.1
unnamed: MX38.3 (LED), R49.1
unnamed: MX39.3 (LED), R50.1
unnamed: MX40.3 (LED), R51.1
unnamed: MX41.3 (LED), R52.1
unnamed: MX42.3 (LED), R53.1
unnamed: MX43.3 (LED), R54.1
unnamed: MX44.3 (LED), R55.1
unnamed: MX45.3 (LED), R56.1
unnamed: MX46.3 (LED), R57.1
unnamed: MX47.3 (LED), R58.1
unnamed: MX48.3 (LED), R59.1
unnamed: MX49.3 (LED), R60.1
unnamed: MX50.3 (LED), R61.1
unnamed: MX55.3 (LED), R66.1
unnamed: MX56.3 (LED), R67.1
unnamed: MX57.3 (LED), R68.1
unnamed: MX58.3 (LED), R69.1
unnamed: MX59.3 (LED), R70.1
unnamed: MX60.3 (LED), R71.1
unnamed: MX61.3 (LED), R72.1
unnamed: MX62.3 (LED), R73.1
unnamed: MX63.3 (LED), R74.1
unnamed: MX64.3 (LED), R75.1
unnamed: MX65.3 (LED), R76.1
unnamed: MX66.3 (LED), R77.1
unnamed: MX67.3 (LED), R78.1
unnamed: MX68.3 (LED), R79.1
unnamed: MX72.3 (LED), R83.1
unnamed: MX73.3 (LED), R84.1
unnamed: MX74.3 (LED), R85.1
unnamed: MX75.3 (LED), R86.1
unnamed: MX76.3 (LED), R87.1
unnamed: MX77.3 (LED), R88.1
unnamed: MX78.3 (LED), R89.1
unnamed: MX79.3 (LED), R90.1
unnamed: MX80.3 (LED), R91.1
unnamed: MX81.3 (LED), R92.1
unnamed: MX82.3 (LED), R93.1
unnamed: MX83.3 (LED), R94.1
unnamed: MX84.3 (LED), R95.1
unnamed: MX85.3 (LED), R96.1
unnamed: MX90.3 (LED), R101.1
unnamed: MX91.3 (LED), R102.1
unnamed: MX92.3 (LED), R103.1
unnamed: MX93.3 (LED), R104.1
unnamed: MX94.3 (LED), R105.1
unnamed: MX95.3 (LED), R106.1
unnamed: MX96.3 (LED), R107.1
unnamed: MX97.3 (LED), R108.1
unnamed: MX98.3 (LED), R109.1
unnamed: MX99.3 (LED), R110.1
col0: MX1.1 (COL), MX16.1 (COL), MX35.1 (COL), MX55.1 (COL), MX72.1 (COL), MX90.1 (COL); also elsewhere on the board
col1: MX17.1 (COL), MX36.1 (COL), MX91.1 (COL); also elsewhere on the board
col2: MX2.1 (COL), MX18.1 (COL), MX37.1 (COL), MX56.1 (COL), MX73.1 (COL), MX92.1 (COL); also elsewhere on the board
col3: MX3.1 (COL), MX19.1 (COL), MX38.1 (COL), MX57.1 (COL), MX74.1 (COL); also elsewhere on the board
col4: MX4.1 (COL), MX20.1 (COL), MX39.1 (COL), MX58.1 (COL), MX75.1 (COL); also elsewhere on the board
col5: MX5.1 (COL), MX21.1 (COL), MX40.1 (COL), MX59.1 (COL), MX76.1 (COL); also elsewhere on the board
col6: MX6.1 (COL), MX22.1 (COL), MX41.1 (COL), MX60.1 (COL), MX77.1 (COL), MX93.1 (COL); also elsewhere on the board
col7: MX7.1 (COL), MX23.1 (COL), MX42.1 (COL), MX61.1 (COL), MX78.1 (COL); also elsewhere on the board
col8: MX8.1 (COL), MX24.1 (COL), MX43.1 (COL), MX62.1 (COL), MX79.1 (COL); also elsewhere on the board
col9: MX9.1 (COL), MX25.1 (COL), MX44.1 (COL), MX63.1 (COL), MX80.1 (COL), MX94.1 (COL); also elsewhere on the board
col10: MX10.1 (COL), MX26.1 (COL), MX45.1 (COL), MX64.1 (COL), MX81.1 (COL), MX95.1 (COL); also elsewhere on the board
col11: MX11.1 (COL), MX27.1 (COL), MX46.1 (COL), MX65.1 (COL), MX82.1 (COL), MX96.1 (COL); also elsewhere on the board
col12: MX12.1 (COL), MX28.1 (COL), MX47.1 (COL), MX66.1 (COL), MX83.1 (COL), MX97.1 (COL); also elsewhere on the board
col13: MX13.1 (COL), MX29.1 (COL), MX48.1 (COL), MX67.1 (COL), MX84.1 (COL), MX98.1 (COL); also elsewhere on the board
col14: MX14.1 (COL), MX49.1 (COL); also elsewhere on the board
col15: MX15.1 (COL), MX30.1 (COL), MX50.1 (COL), MX68.1 (COL), MX85.1 (COL), MX99.1 (COL); also elsewhere on the board
row0: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K); also elsewhere on the board
row1: D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K); also elsewhere on the board
row2: D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K); also elsewhere on the board
row3: D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K); also elsewhere on the board
row4: D78.1 (K), D79.1 (K), D80.1 (K), D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K), D85.1 (K), D86.1 (K), D87.1 (K), D88.1 (K), D89.1 (K), D90.1 (K), D91.1 (K); also elsewhere on the board
row5: D96.1 (K), D97.1 (K), D98.1 (K), D99.1 (K), D100.1 (K), D101.1 (K), D102.1 (K), D103.1 (K), D104.1 (K), D105.1 (K); also elsewhere on the board

Board: 2 copper layers, 304.8 x 160.2 mm, 296 parts (0 on the bottom side), 215 nets.

Other parts of the board:
MOUNT1, MOUNT2, MOUNT3, MOUNT4, MOUNT5, MOUNT6, MOUNT7, MOUNT8, MOUNT9, MOUNT10, MOUNT11, MOUNT12, MOUNT13, MOUNT14: MountingHole_2.2mm_M2_Pad

## Commit log

2021-08-25 Initial directory setup
2021-08-26 Fix merge issues
2021-08-26 Finish initial schematics
2021-08-26 Add initial QMK firmware files
2021-08-26 Cleanup schematics and generate PDFs
2021-08-26 Create QMK firmware
2021-08-27 Shifted numpad down
2021-08-27 Revise schematics to not have detachable numpad
2021-08-27 too many/too few commas
2021-08-27 Finish footprint assignments
2021-08-27 Begin PCB Layout
2021-08-27 reverted numpad changes
2021-08-27 Added detachable numpad message
2021-08-27 Begin revised PCB layout
2021-08-28 Finish rough Resistor and Diode layout
2021-08-28 Fix mismatched pin
2021-08-28 Continue PCB Layout
2021-08-28 Added copper planes
2021-08-28 removed some silk screens, added some, moved stuff around
2021-08-28 adjusted edge cuts to be square
2021-08-28 moved capacitors
2021-08-28 moved holes
2021-08-28 flushed connector, centered
2021-08-28 Finish layout for numpad PCB
2021-08-28 Fix mounting hole
2021-08-28 Move silkscreen for numpad
2021-08-28 Cleanup
2021-08-28 reordered diodes to allow for easier traces
2021-08-28 began traces on main board
2021-08-28 Finish numpad routing
2021-08-29 Rearrange main board diodes
2021-08-30 Finish routing main PCB
2021-08-30 Freerouting work
2021-08-30 Revert freerouting
2021-08-30 Finish PCB Silkscreen Decor
2021-09-05 Fix wrong pinout on MOSFET
2021-09-07 Fix USB footprint
2021-09-07 Fix pin issue in schematic and netlist
2021-09-09 Finish final PCB checks
2021-09-10 Generate gerbers and update schematics
2021-09-10 Update gerbers
2021-09-18 Add backplace acrylic svgs
2021-09-18 Regenerate backplate files as dxf
2021-09-18 Generate acrylic svgs
2021-09-18 updated svg to have edge cuts
2021-09-18 Remove acrylic files
2021-09-18 Finish dwg for main board backplate
2021-09-18 numpad backplate/frontplate
2021-09-18 rename files
2021-09-18 added front plate to main, renamed files
2021-09-18 moved 1 mm up bottom line
2021-09-18 Add acrylic cut files
2021-09-27 fixed eps issue, exported
2021-10-19 enabled backlight
2021-10-19 revert
2021-10-19 added togglekey in replacement of right gui key, added control layer
2021-10-19 basic toggle setup for backlight, more specifics coming
2021-10-19 added increase/decrease brightness keys
2021-10-20 updated breathe time
2021-10-20 added toggle on w
2021-10-20 added shift back/forward and play/pause to control layer
2021-10-20 setup for custom keys
2021-10-31 Cleanup and documenting
